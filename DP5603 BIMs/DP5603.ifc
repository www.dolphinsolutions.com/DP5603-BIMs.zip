Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView]
Time: 2019-12-06T11:27:31
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Dec 06 11:27:31 2019 * Host: BIM-HP * Database: C:\Users\dcole\AppData\Local\Temp\{99DE9FDE-F5DA-4279-88A1-B6122D421308}\ifc * Database version: 5507 * Database creation date: Fri Dec 06 11:27:29 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Dec 06 11:27:29 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Dec 06 11:27:29 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: P:\Fastrack\53721_DOLPHIN SOLUTIONS LIMITED\ADDITIONAL DRAWINGS 2019 BIM\12$DECEMBER\DP5603.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Identity Data - Name: Level 1; Structural: no; Building Story: yes
Dimensions - Computation Height: 0 mm
Graphics - Line Weight: 1; Color: 0; Line Pattern: -3000010; Symbol at End 2 Default: yes; Symbol at End 1 Default: no

# IfcBuildingElementProxy: DP5063 Dolphin Under-Counter Waste Bin, DP5603:DP5063 Dolphin Under-Counter Waste Bin:40543
In: Level 1
Material: Stainless Steel
Constraints - Offset: 0 mm; Level: Level: Level 1; Moves With Nearby Elements: no; Host: Level : Level 1
Dimensions - Volume: 0.0518524 m3; Width: 298mm; Projection: 310mm; Height: 448mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: Dolphin Solutions Limited
Pset_BuildingElementProxyCommon - Reference: DP5063 Dolphin Under-Counter Waste Bin
Identity Data - Assembly Description: Misc. Other Plumbing Systems; Email: info@dolphinsolutions.co.uk; Tel No.: +44 (0) 1424 202224; Assembly Code: D2090900; Model: DP5603; Fax No.: +44 (0) 1424 205200; Address: Southpoint, Compass Park, Bodiam, Robertbridge, TN32 5BS; URL: www.dolphinsolutions.co.uk; Description: Under-counter waste bin; Manufacturer: Dolphin Solutions Limited
General - Product Page Link: http://www.dolphinsolutions.co.uk/en/en/products/under-counter-waste-bin-3; Product Data: Superior quality and timeless design for prestigious washrooms. Easy-care 18/10 chrome nickel stainless steel. Satin finish, welded corners - no sharp edges. Lockable under counter bin. Waste towels disposed-of through a self-closing, fire preventive swing flap. Mesh basket makes disposal easier. A console is an optional extra, specify dimensions back to wall when ordering. 18 litre capacity. Also available in polished stainless steel or plastic powder coated to a colour of your choice.; Capacity Bin: 18 litres
Materials and Finishes - Finish: Satin finish. Also available in polished stainless steel or plastic powder coated to a colour of your choice
